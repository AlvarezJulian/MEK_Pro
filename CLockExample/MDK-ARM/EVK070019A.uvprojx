# Keil uVision project EVK070019A.uvprojx, settings and files
target EVK070019A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: EVK070019A +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx,USE_BPP=16
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x90000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\EVK070019A.sct
  link misc: --keep bootloader.o(bootloader_section)
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
    ./: bootloader.s
  group Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
